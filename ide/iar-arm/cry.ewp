# IAR project cry.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L443CC ST STM32L443CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\..\include; ..\..\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: cry.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../src/: misc.c misc.h version.c
  group crc
    ../../src/crc/: crc16.c crc16_ccitt.c crc16_dnp.c crc16_ibm.c crc32.c crc32_eth.c
  group crypt
    ../../src/crypt/: aes.c affine.c arc4.c base64.c cbc.c cfb.c cmac.c ctr.c des.c dh.c dsa.c ecdh.c ecdsa.c elgamal.c gcm.c hill.c hmac.c memxor.c memxor.h rsa.c trivium.c
  group ecp
    ../../src/ecp/: ecp_add.c ecp_core.c ecp_curves.c ecp_dbl.c ecp_list.c ecp_mul.c
  group hash
    ../../src/hash/: md5.c sha1.c sha256.c
  group mpi
    ../../src/mpi/: mpi_abs.c mpi_add.c mpi_add_abs.c mpi_bin.c mpi_cmp.c mpi_cmp_abs.c mpi_core.c mpi_div.c mpi_div_abs.c mpi_exp.c mpi_gcd.c mpi_inv.c mpi_lcm.c mpi_list.c mpi_mod_exp.c mpi_mul.c mpi_mul_abs.c mpi_mul_baseline.c mpi_mul_comba.c mpi_mul_karatsuba.c mpi_mul_toom3.c mpi_prime.c mpi_pvt.h mpi_rand.c mpi_shl.c mpi_shr.c mpi_sqr.c mpi_sqrt.c mpi_str.c mpi_sub.c mpi_sub_abs.c
  group prng
    ../../src/prng/: prng_aes.c prng_lfsr113.c
